KBUILD_DEFCONFIG_s5pv210 ?= "s5pv210_defconfig"
COMPATIBLE_MACHINE = "s5pv210"
